## configs/fs_defconfig
```kconfig
CONFIG_PLATFORM_FS=y

CONFIG_ESTIMATOR_AUTO_SELECT=y
CONFIG_CONTROLLER_PID=y

CONFIG_DECK_FORCE="bcServo"
CONFIG_DECK_SERVO=y
```
